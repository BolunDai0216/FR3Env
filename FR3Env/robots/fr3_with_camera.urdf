Commit message: commented out camera model

File: FR3Env/robots/fr3_with_camera.urdf (robot description, URDF)
Before this commit: robot fr3, 14 links, 13 joints
Links:
- link camera: geometry 
