Commit message: changed fr3_hand_crude size

File: FR3Env/robots/fr3_hand_crude.urdf (robot description, URDF)
Before this commit: robot fr3_hand_robot, 1 links, 0 joints
Links:
- link base_link: geometry visual box size=0.10 0.24 0.18
